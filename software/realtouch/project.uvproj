# Keil uVision project project.uvproj, settings and files
target RTThread (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\..\..\RT-Thread-Trunk\components\dfs;..\..\..\..\RT-Thread-Trunk\components\dfs\filesystems\devfs;..\..\..\..\RT-Thread-Trunk\components\dfs\filesystems\romfs;..\..\..\..\RT-Thread-Trunk\components\dfs\include;..\..\..\..\RT-Thread-Trunk\components\drivers\include;..\..\..\..\RT-Thread-Trunk\components\drivers\usb\usbhost;..\..\..\..\RT-Thread-Trunk\components\drivers\usb\usbhost\class;..\..\..\..\RT-Thread-Trunk\components\drivers\usb\usbhost\core;..\..\..\..\RT-Thread-Trunk\components\drivers\usb\usbhost\include;..\..\..\..\RT-Thread-Trunk\components\external\jpeg;..\..\..\..\RT-Thread-Trunk\components\external\libpng;..\..\..\..\RT-Thread-Trunk\components\external\libz;..\..\..\..\RT-Thread-Trunk\components\finsh;..\..\..\..\RT-Thread-Trunk\components\pthreads;..\..\..\..\RT-Thread-Trunk\components\rtgui\common;..\..\..\..\RT-Thread-Trunk\components\rtgui\include;..\..\..\..\RT-Thread-Trunk\components\rtgui\server;..\..\..\..\RT-Thread-Trunk\components\rtgui\widgets;..\..\..\..\RT-Thread-Trunk\include;..\..\..\..\RT-Thread-Trunk\libcpu\arm\common;..\..\..\..\RT-Thread-Trunk\libcpu\arm\cortex-m4;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;applications;drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c realtouc_gui.c startup.c
  group Drivers
    drivers/: board.c platform.c usart.c ext_sram.c stm32f4xx_it.c sdio_sd.c stm32f20x_40x_spi.c ra8875.c key.c touch.c stm32f4xx_hcd.c usb_bsp.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    STM32F4xx_Libraries/STM32_USB_HOST_Library/Core/src/: usbh_hcs.c usbh_ioreq.c
    STM32F4xx_Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../../../RT-Thread-Trunk/src/: assert.c clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../../RT-Thread-Trunk/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../RT-Thread-Trunk/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../../RT-Thread-Trunk/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../../../RT-Thread-Trunk/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../RT-Thread-Trunk/components/dfs/filesystems/elmfat/option/: cc936.c
    ../../../../RT-Thread-Trunk/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../../../RT-Thread-Trunk/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    ../../../../RT-Thread-Trunk/components/drivers/serial/: serial.c
    ../../../../RT-Thread-Trunk/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../RT-Thread-Trunk/components/drivers/src/: completion.c ringbuffer.c
    ../../../../RT-Thread-Trunk/components/drivers/usb/usbhost/core/: core.c driver.c usbhost.c hub.c
    ../../../../RT-Thread-Trunk/components/drivers/usb/usbhost/class/: adk.c mass.c
    ../../../../RT-Thread-Trunk/components/drivers/usb/usbhost/udev/: adkapp.c udisk.c
  group jpeg
    ../../../../RT-Thread-Trunk/components/external/jpeg/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdtrans.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctfst.c jidctflt.c jidctint.c jdsample.c jdcolor.c jquant1.c jquant2.c jdmerge.c jmemnobs.c
  group libpng
    ../../../../RT-Thread-Trunk/components/external/libpng/: png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group libz
    ../../../../RT-Thread-Trunk/components/external/libz/: adler32.c compress.c crc32.c deflate.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
  group finsh
    ../../../../RT-Thread-Trunk/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group pthreads
    ../../../../RT-Thread-Trunk/components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
  group RTGUI
    ../../../../RT-Thread-Trunk/components/rtgui/common/: blit.c color.c region.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c dc.c dc_hw.c dc_buffer.c dc_client.c filerw.c image.c image_xpm.c image_hdc.c image_bmp.c image_png.c image_jpg.c image_container.c font.c font_bmp.c font_hz_file.c font_hz_bmp.c asc12font.c asc16font.c hz12font.c hz16font.c framebuffer_driver.c pixel_driver.c
    ../../../../RT-Thread-Trunk/components/rtgui/server/: rtgui_application.c driver.c mouse.c server.c topwin.c
    ../../../../RT-Thread-Trunk/components/rtgui/widgets/: box.c button.c checkbox.c combobox.c iconbox.c label.c textview.c listctrl.c menu.c progressbar.c radiobox.c slider.c scrollbar.c staticline.c textbox.c listbox.c title.c toplevel.c notebook.c container.c list_view.c about_view.c filelist_view.c widget.c window.c
