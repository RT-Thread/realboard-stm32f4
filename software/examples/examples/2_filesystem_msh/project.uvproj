# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\..\RT-Thread\components\dfs;..\..\..\RT-Thread\components\dfs\filesystems\devfs;..\..\..\RT-Thread\components\dfs\include;..\..\..\RT-Thread\components\drivers\include;..\..\..\RT-Thread\components\finsh;..\..\..\RT-Thread\components\init;..\..\..\RT-Thread\components\pthreads;..\..\..\RT-Thread\include;..\..\..\RT-Thread\libcpu\arm\common;..\..\..\RT-Thread\libcpu\arm\cortex-m4;..\..\STM32F4xx_Libraries\CMSIS\Include;..\..\STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;..\..\STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32F4xx_Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\STM32F4xx_Libraries\STM32_USB_Device_Library\Core\inc;..\..\STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;..\..\STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;..\..\drivers;applications
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group STM32_StdPeriph
    ../../STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Drivers
    ../../drivers/: board.c platform.c usart.c ext_sram.c stm32f4xx_it.c sdio_sd.c
  group Applications
    applications/: application.c startup.c
  group Kernel
    ../../../RT-Thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../RT-Thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../RT-Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../RT-Thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../../RT-Thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../RT-Thread/components/dfs/filesystems/elmfat/option/: cc936.c
    ../../../RT-Thread/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    ../../../RT-Thread/components/drivers/serial/: serial.c
    ../../../RT-Thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../../RT-Thread/components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../../RT-Thread/components/init/: components.c
  group pthreads
    ../../../RT-Thread/components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
