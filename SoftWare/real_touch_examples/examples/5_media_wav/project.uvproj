# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\..\..\..\rt-thread_svn\trunk\components\dfs;..\..\..\..\..\rt-thread_svn\trunk\components\dfs\filesystems\romfs;..\..\..\..\..\rt-thread_svn\trunk\components\dfs\include;..\..\..\..\..\rt-thread_svn\trunk\components\drivers\include;..\..\..\..\..\rt-thread_svn\trunk\components\finsh;..\..\..\..\..\rt-thread_svn\trunk\include;..\..\..\..\..\rt-thread_svn\trunk\libcpu\arm\common;..\..\..\..\..\rt-thread_svn\trunk\libcpu\arm\cortex-m4;..\..\STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F4xx_Libraries\CMSIS\Include;..\..\STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;..\..\STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\drivers;applications
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group STM32_StdPeriph
    ../../STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Drivers
    ../../drivers/: board.c serial.c usart.c stm32f4xx_it.c sdio_sd.c stm32_i2c.c codec_wm8978_i2c.c bsp_i2c_gpio.c
  group Applications
    applications/: application.c startup.c wav.c
  group Kernel
    ../../../../../rt-thread_svn/trunk/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../../../rt-thread_svn/trunk/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../../rt-thread_svn/trunk/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../../../rt-thread_svn/trunk/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../../../../rt-thread_svn/trunk/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../../rt-thread_svn/trunk/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    ../../../../../rt-thread_svn/trunk/components/drivers/i2c/: i2c_core.c
  group finsh
    ../../../../../rt-thread_svn/trunk/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
